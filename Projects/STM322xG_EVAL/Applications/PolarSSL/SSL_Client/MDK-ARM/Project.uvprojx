# Keil uVision project Project.uvprojx, settings and files
target STM322xG-EVAL (5060020::V5.06 (build 20)::ARMCC)
  device: STM32F217IG STMicroelectronics
  pack: Keil.STM32F2xx_DFP.2.3.0
  cpu: IRAM(0x20000000-0x2001FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M3")
  output: STM322xG-EVAL
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F217xx,USE_STM322xG_EVAL
  c misc: --C99
  c include: ..\Inc;..\..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32F2xx\Include;..\..\..\..\..\..\Drivers\CMSIS\Include;..\..\..\..\..\..\Drivers\STM32F2xx_HAL_Driver\Inc;..\..\..\..\..\..\Drivers\BSP\STM322xG_EVAL;..\..\..\..\..\..\Drivers\BSP\Components\Common;..\..\..\..\..\..\Drivers\BSP\Components;..\..\..\..\..\..\Middlewares\Third_Party\LwIP\src\include\;..\..\..\..\..\..\Middlewares\Third_Party\LwIP\src\include\ipv4;..\..\..\..\..\..\Middlewares\Third_Party\LwIP\system;..\..\..\..\..\..\Middlewares\Third_Party\LwIP\system\OS;..\..\..\..\..\..\Middlewares\Third_Party\FreeRTOS\Source\portable\RVDS\ARM_CM3;..\..\..\..\..\..\Middlewares\Third_Party\FreeRTOS\Source\;..\..\..\..\..\..\Middlewares\Third_Party\FreeRTOS\Source\CMSIS_RTOS;..\..\..\..\..\..\Middlewares\Third_Party\FreeRTOS\Source\include;..\..\..\..\..\..\Middlewares\Third_Party\polarssl\include;..\..\..\..\..\..\Utilities;..\..\..\..\..\..\Utilities\Fonts
  asm include: ROJ_DIR$\..\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  link misc: --diag_suppress=L6329
  group Application/MDK-ARM
    ./: startup_stm32f217xx.s
  group Middlewares/FreeRTOS
    ../../../../../../Middlewares/Third_Party/FreeRTOS/Source/: tasks.c croutine.c list.c queue.c timers.c
  group Middlewares/FreeRTOS/portable
    ../../../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM3/: port.c
    ../../../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
  group Application/User
    ../Src/: stm32f2xx_it.c main.c app_ethernet.c ethernetif.c stm32f2xx_hal_msp.c ssl_client.c
    ./: retarget.c
  group Drivers/CMSIS
    ../Src/: system_stm32f2xx.c
  group Drivers/BSP/STM322xG_EVAL
    ../../../../../../Drivers/BSP/STM322xG_EVAL/: stm322xg_eval.c stm322xg_eval_sram.c stm322xg_eval_io.c stm322xg_eval_lcd.c
  group Middlewares/LwIP/Core
    ../../../../../../Middlewares/Third_Party/LwIP/src/core/: tcp_in.c raw.c tcp.c def.c stats.c mem.c init.c pbuf.c dns.c lwip_timers.c udp.c netif.c dhcp.c tcp_out.c memp.c sys.c
  group Doc
    ../: readme.txt
  group Middlewares/LwIP/Core/IPv4
    ../../../../../../Middlewares/Third_Party/LwIP/src/core/ipv4/: ip_addr.c igmp.c ip.c ip_frag.c autoip.c inet.c inet_chksum.c icmp.c
  group Drivers/BSP/Components
    ../../../../../../Drivers/BSP/Components/ili9320/: ili9320.c
    ../../../../../../Drivers/BSP/Components/ili9325/: ili9325.c
    ../../../../../../Drivers/BSP/Components/stmpe811/: stmpe811.c
  group Middlewares/FreeRTOS/CMSIS_RTOS
    ../../../../../../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
  group Middlewares/PolarSSL
    ../../../../../../Middlewares/Third_Party/PolarSSL/library/: certs.c entropy.c debug.c asn1write.c md4.c sha2.c ssl_tls.c md_wrap.c dhm.c timing.c asn1parse.c blowfish.c cipher_wrap.c ssl_cache.c version.c aes.c net.c arc4.c base64.c ssl_cli.c x509write.c padlock.c pkcs12.c sha4.c gcm.c sha1.c cipher.c md5.c x509parse.c md2.c bignum.c pem.c des.c md.c rsa.c error.c pkcs5.c camellia.c ctr_drbg.c pkcs11.c xtea.c entropy_poll.c havege.c ssl_srv.c pbkdf2.c
  group Drivers/STM32F2xx_HAL_Driver
    ../../../../../../Drivers/STM32F2xx_HAL_Driver/Src/: stm32f2xx_hal_eth.c stm32f2xx_hal_pwr.c stm32f2xx_hal_gpio.c stm32f2xx_hal_sram.c stm32f2xx_hal_flash_ex.c stm32f2xx_hal_rcc.c stm32f2xx_hal_i2c.c stm32f2xx_hal_cryp.c stm32f2xx_hal_rcc_ex.c stm32f2xx_hal_uart.c stm32f2xx_hal_pwr_ex.c stm32f2xx_hal_rng.c stm32f2xx_hal_hash.c stm32f2xx_hal_cortex.c stm32f2xx_ll_fsmc.c stm32f2xx_hal_flash.c stm32f2xx_hal.c stm32f2xx_hal_dma.c
  group Middlewares/LwIP/Api
    ../../../../../../Middlewares/Third_Party/LwIP/src/api/: netifapi.c err.c netbuf.c sockets.c api_lib.c tcpip.c api_msg.c netdb.c
  group Middlewares/LwIP/Netif
    ../../../../../../Middlewares/Third_Party/LwIP/system/OS/: sys_arch.c
    ../../../../../../Middlewares/Third_Party/LwIP/src/netif/: etharp.c
software components: CMSIS:CORE 4.1.0
