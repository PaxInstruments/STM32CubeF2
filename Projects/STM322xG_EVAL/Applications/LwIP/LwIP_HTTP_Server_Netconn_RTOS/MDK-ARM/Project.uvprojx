# Keil uVision project Project.uvprojx, settings and files
target STM322xG_EVAL (ARM-ADS)
  device: STM32F207IGHx STMicroelectronics
  pack: Keil.STM32F2xx_DFP.2.3.0
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: STM322xG_EVAL
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F207xx,USE_STM322xG_EVAL
  c misc: --C99
  c include: ..\Inc;..\..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32F2xx\Include;..\..\..\..\..\..\Drivers\CMSIS\Include;..\..\..\..\..\..\Drivers\STM32F2xx_HAL_Driver\Inc;..\..\..\..\..\..\Drivers\BSP\STM322xG_EVAL;..\..\..\..\..\..\Drivers\BSP\Components;..\..\..\..\..\..\Middlewares\Third_Party\LwIP\src\include\;..\..\..\..\..\..\Middlewares\Third_Party\LwIP\src\include\ipv4                                                              ;..\..\..\..\..\..\Middlewares\Third_Party\LwIP\system;..\..\..\..\..\..\Middlewares\Third_Party\FreeRTOS\Source\portable\RVDS\ARM_CM3;..\..\..\..\..\..\Middlewares\Third_Party\FreeRTOS\Source\;..\..\..\..\..\..\Middlewares\Third_Party\FreeRTOS\Source\CMSIS_RTOS;..\..\..\..\..\..\Middlewares\Third_Party\FreeRTOS\Source\include;..\..\..\..\..\..\Utilities;..\..\..\..\..\..\Utilities\Log
  asm include: ROJ_DIR$\..\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  link misc: --diag_suppress=L6329
  group Doc
    ../: readme.txt
  group Drivers/STM32F2xx_HAL_Driver
    ../../../../../../Drivers/STM32F2xx_HAL_Driver/Src/: stm32f2xx_hal_cortex.c stm32f2xx_hal_uart.c stm32f2xx_hal_eth.c stm32f2xx_hal_i2s.c stm32f2xx_hal_flash_ex.c stm32f2xx_hal_pwr.c stm32f2xx_hal_rcc.c stm32f2xx_hal.c stm32f2xx_hal_flash.c stm32f2xx_hal_sram.c stm32f2xx_ll_fsmc.c stm32f2xx_hal_i2c.c stm32f2xx_hal_gpio.c stm32f2xx_hal_dma.c
  group Middlewares/LwIP/Core
    ../../../../../../Middlewares/Third_Party/LwIP/src/core/: tcp_in.c lwip_timers.c def.c memp.c netif.c dhcp.c udp.c mem.c stats.c tcp.c tcp_out.c raw.c init.c sys.c pbuf.c dns.c
  group Middlewares/LwIP/Core/IPv4
    ../../../../../../Middlewares/Third_Party/LwIP/src/core/ipv4/: igmp.c ip_addr.c ip_frag.c inet.c inet_chksum.c autoip.c ip.c icmp.c
  group Application/MDK-ARM
    ./: startup_stm32f207xx.s
  group Application/User
    ../Src/: stm32f2xx_it.c fs.c ethernetif.c main.c app_ethernet.c httpserver-netconn.c
  group Middlewares/FreeRTOS
    ../../../../../../Middlewares/Third_Party/FreeRTOS/Source/: timers.c tasks.c queue.c croutine.c list.c
  group Middlewares/FreeRTOS/portable
    ../../../../../../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    ../../../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM3/: port.c
    ../../../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
  group Middlewares/LwIP/Netif
    ../../../../../../Middlewares/Third_Party/LwIP/system/OS/: sys_arch.c
    ../../../../../../Middlewares/Third_Party/LwIP/src/netif/: etharp.c
  group Middlewares/LwIP/Api
    ../../../../../../Middlewares/Third_Party/LwIP/src/api/: netbuf.c err.c sockets.c api_msg.c tcpip.c api_lib.c netifapi.c netdb.c
  group Drivers/CMSIS
    ../Src/: system_stm32f2xx.c
  group Drivers/BSP/STM322xG_EVAL
    ../../../../../../Drivers/BSP/STM322xG_EVAL/: stm322xg_eval_io.c stm322xg_eval.c stm322xg_eval_sram.c stm322xg_eval_lcd.c
  group Application/Utilities
    ../../../../../../Utilities/Log/: lcd_log.c
  group Drivers/BSP/Components
    ../../../../../../Drivers/BSP/Components/ili9320/: ili9320.c
    ../../../../../../Drivers/BSP/Components/ili9325/: ili9325.c
    ../../../../../../Drivers/BSP/Components/stmpe811/: stmpe811.c
software components: CMSIS:CORE 4.1.0
