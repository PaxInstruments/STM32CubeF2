# Keil uVision project Project.uvprojx, settings and files
target STM322xG-EVAL_USBH (5060020::V5.06 (build 20)::ARMCC)
  device: STM32F207IGHx STMicroelectronics
  pack: Keil.STM32F2xx_DFP.2.3.0
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: STM322xG-EVAL_USBH
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F207xx,USE_STM322xG_EVAL
  c misc: --C99
  c include: ..\Inc;..\..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32F2xx\Include;..\..\..\..\..\..\Drivers\STM32F2xx_HAL_Driver\Inc;..\..\..\..\..\..\Middlewares\ST\STM32_USB_Host_Library\Core\Inc;..\..\..\..\..\..\Middlewares\ST\STM32_USB_Host_Library\Class\MSC\Inc;..\..\..\..\..\..\Middlewares\ST\STM32_USB_Host_Library\Class\HID\Inc;..\..\..\..\..\..\Middlewares\Third_Party\FatFs\src;..\..\..\..\..\..\Drivers\BSP\STM322xG_EVAL;..\..\..\..\..\..\Utilities\Log
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  link misc: --diag_suppress=L6329
  group Middlewares/FatFs
    ../../../../../../Middlewares/Third_Party/FatFs/src/: ff.c
  group Drivers/BSP/Components
    ../../../../../../Drivers/BSP/Components/stmpe811/: stmpe811.c
    ../../../../../../Drivers/BSP/Components/ili9325/: ili9325.c
    ../../../../../../Drivers/BSP/Components/ili9320/: ili9320.c
  group Drivers/STM32F2xx_HAL_Driver
    ../../../../../../Drivers/STM32F2xx_HAL_Driver/Src/: stm32f2xx_ll_fsmc.c stm32f2xx_hal_dma_ex.c stm32f2xx_hal_flash_ex.c stm32f2xx_hal.c stm32f2xx_hal_gpio.c stm32f2xx_hal_hcd.c stm32f2xx_hal_rcc_ex.c stm32f2xx_hal_rcc.c stm32f2xx_ll_usb.c stm32f2xx_hal_cortex.c stm32f2xx_hal_sram.c stm32f2xx_hal_flash.c stm32f2xx_hal_i2c.c stm32f2xx_hal_uart.c stm32f2xx_hal_dma.c
  group Middlewares/STM32_USBH_Library/Class/MSC
    ../../../../../../Middlewares/ST/STM32_USB_Host_Library/Class/MSC/Src/: usbh_msc_bot.c usbh_msc.c usbh_msc_scsi.c
  group Utilities
    ../../../../../../Utilities/Log/: lcd_log.c
  group Application/MDK-ARM
    ./: startup_stm32f207xx.s
  group Application/User
    ../Src/: usbh_diskio.c main.c dual_menu.c stm32f2xx_it.c usbh_conf.c
  group Middlewares/STM32_USBH_Library/Core
    ../../../../../../Middlewares/ST/STM32_USB_Host_Library/Core/Src/: usbh_ctlreq.c usbh_pipes.c usbh_core.c usbh_ioreq.c
  group Drivers/BSP/STM322xG_EVAL
    ../../../../../../Drivers/BSP/STM322xG_EVAL/: stm322xg_eval.c stm322xg_eval_io.c stm322xg_eval_lcd.c
  group Middlewares/STM32_USBH_Library/Class/HID
    ../../../../../../Middlewares/ST/STM32_USB_Host_Library/Class/HID/Src/: usbh_hid_mouse.c usbh_hid_keybd.c usbh_hid.c usbh_hid_parser.c
  group Drivers/CMSIS
    ../Src/: system_stm32f2xx.c
  group Application/User/MSC
    ../Src/: explorer.c msc_menu.c file_operations.c
  group Application/User/HID
    ../Src/: keyboard.c mouse.c hid_menu.c
  group Doc
    ../: readme.txt
software components: CMSIS:CORE 4.1.0
