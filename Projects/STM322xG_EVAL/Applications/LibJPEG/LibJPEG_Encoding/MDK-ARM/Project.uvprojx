# Keil uVision project Project.uvprojx, settings and files
target STM322xG_EVAL (5060020::V5.06 (build 20)::ARMCC)
  device: STM32F207IGHx STMicroelectronics
  pack: Keil.STM32F2xx_DFP.2.3.0
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: STM322xG_EVAL
  c flags: Optim=4 oTime=1 OneElfS=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F207xx,USE_STM322xG_EVAL
  c misc: --C99
  c include: ..\Inc;..\..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32F2xx\Include;..\..\..\..\..\..\Drivers\STM32F2xx_HAL_Driver\Inc;..\..\..\..\..\..\Drivers\BSP\STM322xG_EVAL;..\..\..\..\..\..\Middlewares\Third_Party\LibJPEG\include;..\..\..\..\..\..\Middlewares\Third_Party\FatFs\src;..\..\..\..\..\..\Middlewares\Third_Party\FatFs\src\Drivers
  asm include: ROJ_DIR$\..\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  link misc: --diag_suppress=L6329
  group Doc
    ../: readme.txt
  group Drivers/STM32F2xx_HAL_Driver
    ../../../../../../Drivers/STM32F2xx_HAL_Driver/Src/: stm32f2xx_hal_pccard.c stm32f2xx_hal_cortex.c stm32f2xx_hal_hcd.c stm32f2xx_hal_usart.c stm32f2xx_hal_sd.c stm32f2xx_ll_sdmmc.c stm32f2xx_hal_uart.c stm32f2xx_hal_nor.c stm32f2xx_hal_rtc_ex.c stm32f2xx_hal_dma_ex.c stm32f2xx_hal_i2s.c stm32f2xx_hal_adc_ex.c stm32f2xx_hal_iwdg.c stm32f2xx_hal_spi.c stm32f2xx_hal_tim_ex.c stm32f2xx_hal_cryp.c stm32f2xx_hal_rcc_ex.c stm32f2xx_ll_fsmc.c stm32f2xx_hal_i2c.c stm32f2xx_hal_dcmi.c stm32f2xx_hal_pcd_ex.c stm32f2xx_hal_pwr_ex.c stm32f2xx_hal_rng.c stm32f2xx_hal_crc.c stm32f2xx_hal_dac_ex.c stm32f2xx_hal_tim.c stm32f2xx_hal_eth.c stm32f2xx_hal_irda.c stm32f2xx_hal_smartcard.c stm32f2xx_hal_flash_ex.c stm32f2xx_hal_adc.c stm32f2xx_hal_wwdg.c stm32f2xx_hal_pwr.c stm32f2xx_hal_rcc.c stm32f2xx_hal.c stm32f2xx_hal_flash.c stm32f2xx_hal_nand.c stm32f2xx_hal_pcd.c stm32f2xx_hal_sram.c stm32f2xx_hal_can.c stm32f2xx_hal_hash.c stm32f2xx_hal_gpio.c stm32f2xx_hal_dma.c stm32f2xx_ll_usb.c stm32f2xx_hal_dac.c stm32f2xx_hal_rtc.c
  group Application/MDK-ARM
    ./: startup_stm32f207xx.s
  group Application/User
    ../Src/: encode.c stm32f2xx_it.c decode.c main.c
  group Middlewares/Lib_JPEG
    ../../../../../../Middlewares/Third_Party/LibJPEG/source/: jdarith.c jfdctflt.c jcdctmgr.c jidctfst.c jdhuff.c jcparam.c jcapimin.c jdmaster.c jutils.c jchuff.c jcarith.c jcmaster.c jmemnobs.c jquant2.c jdmerge.c jdatadst.c jerror.c jidctflt.c jdsample.c jquant1.c jdmainct.c jddctmgr.c jdapistd.c jcmainct.c jdcolor.c jdpostct.c jidctint.c jccoefct.c jdcoefct.c jdmarker.c jmemmgr.c jdatasrc.c jccolor.c jcinit.c jdinput.c jcapistd.c jcomapi.c jcmarker.c jfdctint.c jdapimin.c jfdctfst.c jctrans.c jaricom.c jdtrans.c jcprepct.c jcsample.c
  group Middlewares/FatFs/Drivers
    ../../../../../../Middlewares/Third_Party/FatFs/src/drivers/: sd_diskio.c
  group Drivers/CMSIS
    ../Src/: system_stm32f2xx.c
  group Drivers/BSP/STM322xG_EVAL
    ../../../../../../Drivers/BSP/STM322xG_EVAL/: stm322xg_eval_io.c stm322xg_eval_sram.c stm322xg_eval_sd.c stm322xg_eval.c stm322xg_eval_lcd.c
  group Drivers/BSP/Components
    ../../../../../../Drivers/BSP/Components/ili9325/: ili9325.c
    ../../../../../../Drivers/BSP/Components/ili9320/: ili9320.c
    ../../../../../../Drivers/BSP/Components/stmpe811/: stmpe811.c
  group Middlewares/FatFs/Core
    ../../../../../../Middlewares/Third_Party/FatFs/src/: ff_gen_drv.c ff.c diskio.c
software components: CMSIS:CORE 4.1.0
