# Keil uVision project Project.uvprojx, settings and files
target STM322xG_EVAL (5060020::V5.06 (build 20)::ARMCC)
  device: STM32F207IGHx STMicroelectronics
  pack: Keil.STM32F2xx_DFP.2.3.0
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: STM322xG_EVAL
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F207xx,USE_STM322xG_EVAL
  c misc: --C99
  c include: ..\Inc;..\..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32F2xx\Include;..\..\..\..\..\..\Drivers\STM32F2xx_HAL_Driver\Inc;..\..\..\..\..\..\Drivers\BSP\STM322xG_EVAL;..\..\..\..\..\..\Middlewares\Third_Party\FatFs\src;..\..\..\..\..\..\Middlewares\Third_Party\FatFs\src\drivers;..\..\..\..\..\..\Middlewares\Third_Party\FreeRTOS\Source\portable\RVDS\ARM_CM3;..\..\..\..\..\..\Middlewares\Third_Party\FreeRTOS\Source\include;..\..\..\..\..\..\Middlewares\Third_Party\FreeRTOS\Source\CMSIS_RTOS
  asm include: ROJ_DIR$\..\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  link misc: --diag_suppress=L6329
  group Doc
    ../: readme.txt
  group Middlewares/FreeRTOS
    ../../../../../../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c timers.c tasks.c queue.c list.c
  group Middlewares/FreeRTOS/CMSIS_RTOS
    ../../../../../../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
  group Drivers/STM32F2xx_HAL_Driver
    ../../../../../../Drivers/STM32F2xx_HAL_Driver/Src/: stm32f2xx_hal.c stm32f2xx_hal_cortex.c stm32f2xx_hal_flash.c stm32f2xx_hal_crc.c stm32f2xx_hal_sram.c stm32f2xx_hal_sd.c stm32f2xx_ll_sdmmc.c stm32f2xx_hal_uart.c stm32f2xx_ll_fsmc.c stm32f2xx_hal_i2c.c stm32f2xx_hal_gpio.c stm32f2xx_hal_i2s.c stm32f2xx_hal_dma.c stm32f2xx_hal_flash_ex.c stm32f2xx_hal_wwdg.c stm32f2xx_hal_pwr.c stm32f2xx_hal_rcc.c
  group Application/MDK-ARM
    ./: startup_stm32f207xx.s
  group Application/User
    ../Src/: stm32f2xx_it.c main.c
  group Middlewares/FreeRTOS/portable
    ../../../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../../../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM3/: port.c
  group Middlewares/FatFs/Options
    ../../../../../../Middlewares/Third_Party/FatFs/src/option/: unicode.c syscall.c
  group Middlewares/FatFs/Drivers
    ../../../../../../Middlewares/Third_Party/FatFs/src/drivers/: sd_diskio.c
  group Drivers/CMSIS
    ../Src/: system_stm32f2xx.c
  group Drivers/BSP/STM322xG_EVAL
    ../../../../../../Drivers/BSP/STM322xG_EVAL/: stm322xg_eval_io.c stm322xg_eval.c stm322xg_eval_sd.c
  group Drivers/BSP/Components
    ../../../../../../Drivers/BSP/Components/stmpe811/: stmpe811.c
  group Middlewares/FatFs/Core
    ../../../../../../Middlewares/Third_Party/FatFs/src/: diskio.c ff_gen_drv.c ff.c
software components: CMSIS:CORE 4.1.0
