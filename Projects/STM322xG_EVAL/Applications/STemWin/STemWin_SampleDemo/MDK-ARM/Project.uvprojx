# Keil uVision project Project.uvprojx, settings and files
target STM322xG_EVAL (5060020::V5.06 (build 20)::ARMCC)
  device: STM32F207IGHx STMicroelectronics
  pack: Keil.STM32F2xx_DFP.2.3.0
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: STM322xG_EVAL
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F207xx,USE_STM322xG_EVAL
  c misc: --C99
  c include: ..\Inc;..\Demo;..\..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32F2xx\Include;..\..\..\..\..\..\Drivers\CMSIS\Include;..\..\..\..\..\..\Drivers\STM32F2xx_HAL_Driver\inc;..\..\..\..\..\..\Drivers\BSP\STM322xG_EVAL;..\..\..\..\..\..\Drivers\BSP\Components\Common;..\..\..\..\..\..\Drivers\BSP\Components;..\..\..\..\..\..\Middlewares\ST\STemWin\inc;..\..\..\..\..\..\Utilities;..\..\..\..\..\..\Utilities\Fonts
  asm include: ROJ_DIR$\..\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  link misc: --diag_suppress=L6329
  group Doc
    ../: readme.txt
  group Drivers/STM32F2xx_HAL_Driver
    ../../../../../../Drivers/STM32F2xx_HAL_Driver/Src/: stm32f2xx_hal_cortex.c stm32f2xx_hal_uart.c stm32f2xx_hal_rtc_ex.c stm32f2xx_hal_tim_ex.c stm32f2xx_ll_fsmc.c stm32f2xx_hal_i2c.c stm32f2xx_hal_crc.c stm32f2xx_hal_tim.c stm32f2xx_hal_flash_ex.c stm32f2xx_hal_pwr.c stm32f2xx_hal_rcc.c stm32f2xx_hal.c stm32f2xx_hal_flash.c stm32f2xx_hal_sram.c stm32f2xx_hal_gpio.c stm32f2xx_hal_dma.c stm32f2xx_hal_rtc.c
  group Application/MDK-ARM
    ./: startup_stm32f207xx.s
  group Application/User
    ../Src/: stm32f2xx_it.c main.c rtc.c calibration.c
  group Application/Demo
    ../Demo/: GUIDEMO_ColorBar.c GUIDEMO.c GUIDEMO_Listview.c GUIDEMO_RadialMenu.c GUIDEMO_Graph.c GUIDEMO_Intro.c GUIDEMO_ImageFlow.c GUIDEMO_Cursor.c GUIDEMO_AntialiasedText.c GUIDEMO_Bitmap.c GUIDEMO_ZoomAndRotate.c GUIDEMO_Automotive.c GUIDEMO_Fading.c GUIDEMO_IconView.c GUIDEMO_Conf.c GUIDEMO_Treeview.c GUIDEMO_VScreen.c GUIDEMO_BarGraph.c GUIDEMO_TransparentDialog.c GUIDEMO_Skinning.c GUIDEMO_Speedometer.c GUIDEMO_Speed.c GUIDEMO_Start.c GUIDEMO_Resource.c GUIDEMO_WashingMachine.c
  group Middlewares/STemWin/Lib
    ../../../../../../Middlewares/ST/STemWin/Lib/: STemWin528_CM3_keil.lib
  group Drivers/CMSIS
    ../Src/: system_stm32f2xx.c
  group Drivers/BSP/STM322xG_EVAL
    ../../../../../../Drivers/BSP/STM322xG_EVAL/: stm322xg_eval_io.c stm322xg_eval_ts.c stm322xg_eval.c
  group Middlewares/STemWin/Config
    ../Src/: GUIConf_stm322xg_eval.c LCDConf_stm322xg_eval.c
    ../../../../../../Middlewares/ST/STemWin/OS/: GUI_X.c
  group Drivers/BSP/Components
    ../../../../../../Drivers/BSP/Components/ili9325/: ili9325.c
    ../../../../../../Drivers/BSP/Components/ili9320/: ili9320.c
    ../../../../../../Drivers/BSP/Components/stmpe811/: stmpe811.c
software components: CMSIS:CORE 4.1.0
