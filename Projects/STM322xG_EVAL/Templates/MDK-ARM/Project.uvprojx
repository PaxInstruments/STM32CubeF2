# Keil uVision project Project.uvprojx, settings and files
target STM322xG-EVAL (5060020::V5.06 (build 20)::ARMCC)
  device: STM32F217IGHx STMicroelectronics
  pack: Keil.STM32F2xx_DFP.2.3.0
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: STM322xG-EVAL
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F217xx,USE_STM322xG_EVAL
  c misc: --C99
  c include: ..\Inc;..\..\..\..\Drivers\CMSIS\Device\ST\STM32F2xx\Include;..\..\..\..\Drivers\STM32F2xx_HAL_Driver\Inc;..\..\..\..\Drivers\BSP\STM322xG_EVAL;..\..\..\..\Drivers\BSP\Components\Common;..\..\..\..\Drivers\BSP\Components\ov2640;..\..\..\..\Drivers\BSP\Components\ili9325;..\..\..\..\Drivers\BSP\Components\stmpe811;..\..\..\..\Drivers\BSP\Components\cs43l22;..\..\..\..\Utilities\Log;..\..\..\..\Utilities\Fonts;..\..\..\..\Utilities\CPU
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  link misc: --diag_suppress=L6329
  group Doc
    ../: readme.txt
  group Example/MDK-ARM
    ./: startup_stm32f217xx.s
  group Drivers/BSP/Components
    ../../../../Drivers/BSP/Components/stmpe811/: stmpe811.c
    ../../../../Drivers/BSP/Components/ili9325/: ili9325.c
    ../../../../Drivers/BSP/Components/ov2640/: ov2640.c
    ../../../../Drivers/BSP/Components/cs43l22/: cs43l22.c
    ../../../../Drivers/STM32F2xx_HAL_Driver/Src/: stm32f2xx_ll_fsmc.c
    ../../../../Drivers/BSP/Components/ili9320/: ili9320.c
  group Drivers/BSP/STM322xG-EVAL
    ../../../../Drivers/BSP/STM322xG_EVAL/: stm322xg_eval_io.c stm322xg_eval_audio.c stm322xg_eval_sram.c stm322xg_eval_sd.c stm322xg_eval_camera.c stm322xg_eval_lcd.c stm322xg_eval.c stm322xg_eval_ts.c
  group Drivers/STM32F2xx_HAL_Driver
    ../../../../Drivers/STM32F2xx_HAL_Driver/Src/: stm32f2xx_hal_i2c.c stm32f2xx_hal_hash.c stm32f2xx_hal_gpio.c stm32f2xx_hal_rtc_ex.c stm32f2xx_hal_dac.c stm32f2xx_hal_i2s.c stm32f2xx_hal_rcc_ex.c stm32f2xx_hal_sram.c stm32f2xx_ll_sdmmc.c stm32f2xx_hal_irda.c stm32f2xx_hal_pcd.c stm32f2xx_hal_dac_ex.c stm32f2xx_hal_pwr_ex.c stm32f2xx_hal_can.c stm32f2xx_hal_nor.c stm32f2xx_hal_rtc.c stm32f2xx_hal_smartcard.c stm32f2xx_hal_tim.c stm32f2xx_hal_usart.c stm32f2xx_hal_wwdg.c stm32f2xx_hal_iwdg.c stm32f2xx_hal_flash_ex.c stm32f2xx_hal_dma.c stm32f2xx_hal_tim_ex.c stm32f2xx_hal_cortex.c stm32f2xx_hal_crc.c stm32f2xx_hal_flash.c stm32f2xx_hal_hcd.c stm32f2xx_hal_rng.c stm32f2xx_hal_dma_ex.c stm32f2xx_hal_eth.c stm32f2xx_hal_pwr.c stm32f2xx_hal_rcc.c stm32f2xx_hal_nand.c stm32f2xx_hal_cryp.c stm32f2xx_hal_sd.c stm32f2xx_hal_uart.c stm32f2xx_hal_dcmi.c stm32f2xx_hal_adc.c stm32f2xx_hal_spi.c stm32f2xx_ll_usb.c stm32f2xx_hal_adc_ex.c stm32f2xx_hal_pccard.c stm32f2xx_hal.c
  group Example/User
    ../Src/: main.c stm32f2xx_hal_msp.c stm32f2xx_it.c
  group Drivers/CMSIS
    ../Src/: system_stm32f2xx.c
software components: CMSIS:CORE 4.1.0
